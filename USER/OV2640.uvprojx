# Keil uVision project OV2640.uvprojx, settings and files
target OV2640 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OV2640 +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\FWLIB\inc;..\USMART;..\HARDWARE\hsl;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\CAR;..\HARDWARE\DUOJI_MATH;..\HARDWARE\DIAO_SHI;..\HARDWARE\ADC;..\HARDWARE\Robotarm;..\HARDWARE\PY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c main.c stm32f4xx_it.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/hsl/: easytrace.c
    ../HARDWARE/MPU6050/: mpu6050.c inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/CAR/: car.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/Robotarm/: Robotarm.c
    ../HARDWARE/PY/: py.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_i2c.c stm32f4xx_adc.c
  group README
    ../: readme.txt
